# Repository dariogjonej/Hackpad

File README.md:

# Hackpad
Hackpad is a 3 key macropad with a rotary encoder. It also has 1 SK6812 MINI-E LED, and uses KMK firmware.

# Features:
EC11 Rotary encoder for whatever you want (personaly i will use it for a volume knob)
1 SK6812 MINI-E LED
3 Switches/Keys for any purpose you want
CAD Model:
Everything fits together using 4 M3x16mm Bolts and M3x5mx4mm heatset inserts for the case.

It has 2 separate printed pieces. The base where the PCB sits and the top cover.

Made in Fusion360.

PCB:
Here's my PCB! It was made in KiCad.

Schematic:

PCB:<br>

# Firmware
This hackpad uses KMK firmware for everything.

The rotary encoder changes volume. Press to play/pause.
The 3 keys currently type 1, 2 and 3. However I can dynamically change the code.
The mini LED is just ON as a static light with a red color.

# BOM:
Here is everything you need to make this hackpad.

3x Cherry MX Switches<br>
3x DSA Keycaps<br>
1x EC11 Rotary encoder<br>
1x SK6812 MINI-E LED<br>
1x Seeed XIAO RP2040<br>
4x M3x5x4 Heatset inserts<br>
4x M3x16mm Screws<br>
1x Case (two 3D printed parts, the base where the PCB sits and the top cover)

## KiCad design PCB/Hackpad.kicad_pcb

Board: 2 copper layers, 42.9 x 61.9 mm, 6 parts (0 on the bottom side), 9 nets.

Parts:
D2: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
SW1, SW3, SW4: SW_Push; SW_Cherry_MX_1.00u_PCB
SW5: RotaryEncoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
U1: XIAO-RP2040-DIP

Connections:
+5V: D2.4 (VDD), U1.14 (VBUS)
GND: D2.2 (VSS), SW1.1, SW3.1, SW4.1, SW5.C, SW5.S1, U1.13 (GND)
unnamed: D2.3 (DIN), U1.4 (GPIO29/ADC3/A3)
unnamed: SW5.A, U1.7 (GPIO0/TX)
unnamed: SW1.2, U1.8 (GPIO1/RX)
unnamed: SW4.2, U1.11 (GPIO3/MOSI)
unnamed: SW3.2, U1.10 (GPIO4/MISO)
unnamed: SW5.S2, U1.5 (GPIO6/SDA)
unnamed: SW5.B, U1.6 (GPIO7/SCL)
